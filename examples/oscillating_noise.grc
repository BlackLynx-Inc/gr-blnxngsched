options:
  parameters:
    generate_options: qt_gui
    id: oscillating_noise
    output_language: python
    title: oscillating_noise
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 0.1e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.03'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '30'
    freq: '0.5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blnxngsched_cuda_mult_0
  id: blnxngsched_cuda_mult
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.02'
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0_0, '0']
- [blnxngsched_cuda_mult_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blnxngsched_cuda_mult_0, '1']
- [blocks_throttle_0_0, '0', blnxngsched_cuda_mult_0, '0']

metadata:
  file_format: 1
